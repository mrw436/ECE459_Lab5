# Keil uVision project mRK.uvprojx, settings and files
target mbed LPC1768 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mRK
  AfterMake: fromelf --bin -o F:\@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: TARGET_LPC1768
  c include: .\mbed;.\mbed\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\mbed\LPC1768\LPC1768.sct
  link misc: .\mbed\LPC1768\startup_LPC17xx.o
.\mbed\LPC1768\system_LPC17xx.o
.\mbed\LPC1768\stackheap.o
.\mbed\LPC1768\core_cm3.o
.\mbed\LPC1768\cmsis_nvic.o
.\mbed\LPC1768\capi.ar
.\mbed\LPC1768\mbed.ar
  group src
    ./mRK/: my_asm.s
    ./mRK/NanoRk/src/platform/: hal_wait.cpp nrk_eeprom.cpp ulib.cpp
    ./mRK/NanoRk/src/kernel/hal/: nrk_cpu.cpp nrk_ext_int.cpp nrk_status.cpp nrk_timer.cpp nrk_watchdog.cpp
    ./mRK/NanoRk/src/kernel/source/: nrk.cpp nrk_driver.cpp nrk_error.cpp nrk_events.cpp nrk_idle_task.cpp nrk_reserve.cpp nrk_scheduler.cpp nrk_stack_check.cpp nrk_stats.cpp nrk_sw_wdt.cpp nrk_task.cpp nrk_time.cpp
    ./mRK/NanoRk/src/drivers/platform/: adc_driver.cpp ff_basic_sensor.cpp
    ./mRK/NanoRk/src/radio/: MRF24J40.cpp basic_rf.cpp
    ./mRK/NanoRk/src/networking/: bmac.cpp
    ./mRK/NanoRk/src/: main.cpp
software components: CMSIS:CORE 5.2.0
